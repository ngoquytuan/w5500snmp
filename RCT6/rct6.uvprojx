# Keil uVision project rct6.uvprojx, settings and files
target wizweb (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rct6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user\FatFs;.\user;.\user\ethernet;.\user\util;.\user\PlatformHandler;.\user\ethernet\W5500;.\user\ethernet\httpServer;.\user\ethernet\SNTP;.\user\ethernet\DNS;.\user\ethernet\SNMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source
    ./user/: main.c
  group handle
    ./user/PlatformHandler/: delay.c stm32f10x_it.c uartHandler.c ioconfig.c timerHandler.c w5500init.c spiconfig.c
    ./user/ethernet/httpServer/: eeprom_stm.c
    ./user/: uartprasing.c
  group web
    ./user/ethernet/DNS/: dns.c
    ./user/ethernet/: ntpserver.c socket.c wizchip_conf.c
    ./user/ethernet/W5500/: w5500.c
    ./user/ethernet/SNTP/: sntp.c
    ./user/ethernet/httpServer/: httpUtil.c httpServer.c httpParser.c ConfigData.c
    ./user/ethernet/SNMP/: snmp_custom.c snmp.c
  group fatfs
    ./user/FatFs/: ff.c ffsystem.c ffunicode.c mmcstm32.c
software components: CMSIS:CORE 5.3.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
